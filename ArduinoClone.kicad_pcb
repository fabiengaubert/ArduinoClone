# Repository fabiengaubert/ArduinoClone

File README.md:

# ArduinoClone
Arduino clone with additional EEPROM

## KiCad design ArduinoClone.kicad_pcb

Parts:
BT1: Battery 3V; PinHeader_1x02_P2.54mm_Vertical
C1, C2: 22pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3: 10uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R1: 330Ohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2: 10KOhm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1, U2: 24LC1025; SOIJ-8_5.3x5.3mm_P1.27mm
U3: DS1337_custom; SO-8_5.3x6.2mm_P1.27mm
U4: ATMEGA328P-AU; TQFP-32_7x7mm; MPN ATMEGA328P-AU; Digi-Key_PN ATMEGA328P-AU-ND
Y1: 32MHz; Crystal_SMD_MicroCrystal_CC7V-T1A-2Pin_3.2x1.5mm_HandSolder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
Y2: 16MHz; Crystal_SMD_5032-2Pin_5.0x3.2mm

Connections:
/ADDS1: U1.1 (A0), U2.1 (A0), U4.23 (PC0)
/ADDS2: U1.2 (A1), U2.2 (A1), U4.24 (PC1)
/D2: U4.32 (PD2); also elsewhere on the board
/D3: U4.1 (PD3); also elsewhere on the board
/D4: U4.2 (PD4); also elsewhere on the board
/D5: U4.9 (PD5); also elsewhere on the board
/D6: U4.10 (PD6); also elsewhere on the board
/D7: U4.11 (PD7); also elsewhere on the board
/D8: U4.12 (PB0); also elsewhere on the board
/MISO: U4.16 (PB4); also elsewhere on the board
/MOSI: U4.15 (PB3); also elsewhere on the board
/RESET: R2.1, U4.29 (PC6); also elsewhere on the board
/RX: U4.30 (PD0); also elsewhere on the board
/SCK: D1.2 (A), U1.6 (SCL), U2.6 (SCL), U3.6 (SCL), U4.28 (PC5); also elsewhere on the board
/SDA: U1.5 (SDA), U2.5 (SDA), U3.5 (SDA), U4.27 (PC4); also elsewhere on the board
/TX: U4.31 (PD1); also elsewhere on the board
/Vcc: BT1.1 (+), C3.1, R2.2, U1.3 (A2), U1.8 (VCC), U2.3 (A2), U2.8 (VCC), U3.3 (INTA), U3.8 (Vcc), U4.4 (VCC), U4.6 (VCC), U4.18 (AVCC); also elsewhere on the board
GNDPWR: BT1.2 (-), C1.2, C2.2, C3.2, R1.2, U1.4 (GND), U1.7 (WP), U2.4 (GND), U2.7 (WP), U3.4 (GND), U4.3 (GND), U4.5 (GND), U4.21 (GND); also elsewhere on the board
unnamed: C1.1, U4.7 (PB6), Y2.1
unnamed: C2.1, U4.8 (PB7), Y2.2
unnamed: D1.1 (K), R1.1
unnamed: U3.1 (X1), Y1.2
unnamed: U3.2 (X2), Y1.1

Parts:
J1: Digital pins; PinSocket_1x09_P2.54mm_Vertical
J2: Serial port; PinSocket_1x04_P2.54mm_Vertical
J3: I2C; PinSocket_1x04_P2.54mm_Vertical
J4: ICSP; PinSocket_2x03_P2.54mm_Vertical

Connections:
/D2: J1.1; also elsewhere on the board
/D3: J1.2; also elsewhere on the board
/D4: J1.3; also elsewhere on the board
/D5: J1.4; also elsewhere on the board
/D6: J1.5; also elsewhere on the board
/D7: J1.6; also elsewhere on the board
/D8: J1.7; also elsewhere on the board
/MISO: J4.1; also elsewhere on the board
/MOSI: J4.4; also elsewhere on the board
/RESET: J4.5; also elsewhere on the board
/RX: J2.3; also elsewhere on the board
/SCK: J3.4, J4.3; also elsewhere on the board
/SDA: J3.3; also elsewhere on the board
/TX: J2.4; also elsewhere on the board
/Vcc: J1.9, J2.2, J3.2, J4.2; also elsewhere on the board
GNDPWR: J1.8, J2.1, J3.1, J4.6; also elsewhere on the board

Notes on the sheet:
SPI Connector
I2C Connector
Serial Connector
GPIO Connector

Board: 2 copper layers, 45.2 x 21.6 mm, 17 parts (0 on the bottom side), 23 nets.

## Commit log

2020-11-28 created sub sheet, added components
2020-11-28 footprints associated to symbols
2020-11-29 finished schematics with comments
2020-11-29 added netlist
2020-11-29 added routes and copper fill
2020-11-29 Gerber, drill and placement files
2021-01-10 added 3D view
